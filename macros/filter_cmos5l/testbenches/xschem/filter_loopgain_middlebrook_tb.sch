** sch_path: macros/filter_cmos5l/testbenches/xschem/filter_loopgain_middlebrook_tb.sch
**.subckt filter_loopgain_middlebrook_tb
VIN vid GND 0
E4 vout1 GND voutp1 voutn1 1
VIINP vip vipp 0
VIINN vin vinn 0
E5 vout GND voutp2 voutn2 1
VIOP vo_opa_n voutn1 0
VION vo_opa_p voutp1 0
E6 vr GND vr_p vr_n 1
Ixn vi_opa_n vinn dc 0 ac 0
Ixp vipp vi_opa_p dc 0 ac 0
Vxn vi_opa_n vr_p dc 0 ac 0.5 180
Vxp vi_opa_p vr_n dc 0 ac 0.5
xamp1 VDD vi_opa_n vi_opa_p vo_opa_p di_pon vo_opa_n GND amp
V3 VDD GND 1.8
V4 di_pon GND 1.8
x2 vip vid vcmi GND vin single2dm
V2 vcmi GND 0.9
R1 net1 net3 {1645*L_R1/W_R} m=1
R4 net1 net2 {1645*L_R1/W_R} m=1
R2 voutn1 net3 {1645*L_R2/W_R} m=1
R7 voutp1 net2 {1645*L_R2/W_R} m=1
R3 net3 vr_n {1645*L_R3/W_R} m=1
R8 net2 vr_p {1645*L_R3/W_R} m=1
R5 voutp1 voutp2 {1645*L_R4/W_R} m=1
R6 voutn1 voutn2 {1645*L_R4/W_R} m=1
C3 net3 net2 {1.287p*L_C1*L_C1} m=1
C1 voutn1 vr_n {1.287p*L_C2*L_C2} m=1
C2 voutp1 vr_p {1.287p*L_C2*L_C2} m=1
C4 voutp2 voutn2 {1.287p*L_C3*L_C3} m=1
**** begin user architecture code


.options savecurrents
.options method=gear reltol=.01
.options sparse
.control
save all

let f_sig = 100
let f_min = 10
let f_max = 100G
let f_stop = 5Meg
let tper_sig = 1/f_sig
let tfr_sig = tper_sig/2
* R2/R1 = 1.3Meg/650k, so beta = R1/(R1+R2) = 1/3 at dc
let Adc = 2
let beta = 1/(1+Adc)
let v_step_o = 0.9
let v_step_i = v_step_o/Adc

let t_rf = 0.1u
let t_step = 50u
let t_delay = 0
let t_per = 2*t_step

let tstep = 0.1*t_rf
let tstop = 2*t_per
let tstart = t_delay

*alter @VIN[SIN] = [ 0 0.01 $&f_sig 0 0 0 ]
alter @VIN[DC] = 0.0

set wr_singlescale
set wr_vecnames
option numdgt=3


** Main Simulations
	* The loop is cut at the amplifier inputs. Vxp and Vxn sit in series between the summing
	* nodes vr_n, vr_p and the gates, Ixp and Ixn inject into the gates, both differentially.
	op

	* run 1, voltage injection: the probe sources carry +-0.5 V, the probe currents are off
	ac dec 100 $&const.f_min $&const.f_max
	let va1 = v(vi_opa_p) - v(vi_opa_n)
	let vb1 = v(vr_n) - v(vr_p)
	let i1 = (i(Vxp) - i(Vxn))/2

	* run 2, current injection: the probe currents carry 1 A differential, the probe sources are off
	alter @Vxp[acmag] = 0
	alter @Vxn[acmag] = 0
	alter @Ixp[acmag] = 1
	alter @Ixn[acmag] = 1
	ac dec 100 $&const.f_min $&const.f_max
	let va2 = v(vi_opa_p) - v(vi_opa_n)
	let i2 = (i(Vxp) - i(Vxn))/2

	* Middlebrook 1975: the voltage and the current loop gain at the cut, exact when nothing flows back
+ through it
	let Tv = -ac1.vb1/ac1.va1
	let Ti = i2/(1 - i2)
	let L = (Tv*Ti - 1)/(Tv + Ti + 2)

	let A = L/beta

	let L_re = real(L)
	let L_im = imag(L)

	let L_dB = vdb(L)
	let L_arg = 180/PI*cphase(L)
	let A_dB = vdb(A)
	let A_arg = 180/PI*cphase(A)

	let fdc = const.f_min+1

	meas ac fug find frequency when L_dB=0
	meas ac pm find L_arg when frequency=fug
	meas ac L_im_zero find L_im when L_re=0

	let pm = 180-abs(pm)

	print pm

	* gain margin, and how close the Nyquist curve comes to -1 anywhere
	meas ac L180_dB find L_dB when L_arg=-180
	let gm = -L180_dB
	print gm
	let L_dist = mag(1+L)
	meas ac dist_min min L_dist
	print dist_min

	meas ac L0_dB find L_dB when frequency = fdc
	let err_gain = 1/(1+10^(L0_dB/20))

	print err_gain

	plot L_dB L_arg A_dB A_arg title 'Bode Plot of Loop Gain' ylabel 'Magnitude (dB) / Phase (Deg)'
	plot L_im vs L_re retraceplot title 'Nyquist Plot of Loop Gain' ylabel 'Imaginary Part' xlabel 'Real Part'

alter @VIN[DC] = 0
op

remzerovec
write filter_loopgain_middlebrook_tb.raw
.endc


.include [file rootname [file tail [xschem get schname]]].save




.lib cornerMOSlv.lib mos_tt
.lib cornerMOShv.lib mos_tt
.lib cornerRES.lib res_typ
.lib cornerDIO.lib dio_tt
.lib cornerCAP.lib cap_typ



**** end user architecture code
**.ends

* expanding   symbol:  amp.sym # of pins=7
** sym_path: amp.sym
** sch_path: amp.sch
.subckt amp VDD VI_N VI_P VO_P di_pon VO_N VSS
*.iopin VSS
*.iopin VDD
*.ipin VI_P
*.ipin di_pon
*.ipin VI_N
*.opin VO_P
*.opin VO_N
xr1 vfb1 vo1_n vo1_p VSS rstring_cm
xr2 vfb2 VO_P VO_N VSS rstring_cm
XM6 vbp vbp VDD VDD sg13_lv_pmos w=0.15u l=0.13u ng=1 m=1 mm_ok=1
XM7 viref1 vbp VDD VDD sg13_lv_pmos w=0.15u l=0.13u ng=1 m=1 mm_ok=1
XM8 VO_N vfb2 VDD VDD sg13_lv_pmos w=0.15u l=0.13u ng=1 m=1 mm_ok=1
XM9 VO_P vfb2 VDD VDD sg13_lv_pmos w=0.15u l=0.13u ng=1 m=1 mm_ok=1
XM10 vbncm vbp VDD VDD sg13_lv_pmos w=0.15u l=0.13u ng=1 m=1 mm_ok=1
XM12 vo1_n vfb1 VSS VSS sg13_lv_nmos w=6u l=0.13u ng=1 m=1 mm_ok=1
XM13 vo1_p vfb1 VSS VSS sg13_lv_nmos w=6u l=0.13u ng=1 m=1 mm_ok=1
XM14 VO_N vo1_p VSS VSS sg13_lv_nmos w=0.15u l=0.13u ng=1 m=1 mm_ok=1
XM15 VO_P vo1_n VSS VSS sg13_lv_nmos w=0.15u l=0.13u ng=1 m=1 mm_ok=1
XM16 vfb2 vbncm VSS VSS sg13_lv_nmos w=0.15u l=0.13u ng=1 m=1 mm_ok=1
XM17 vbncm vbncm VSS VSS sg13_lv_nmos w=0.15u l=0.13u ng=1 m=1 mm_ok=1
XR1 vbp vrref_sw VSS rhigh w=0.5e-6 l=0.96e-6 m=1 b=0 mm_ok=1
XC3 vbp VDD cap_cmomf w=5e-6 l=5e-6 mmin=1 mmax=4 subblock=0 rfmodel=0 subscale=1 m=1 mm_ok=1
XC4 VO_N vfb2 cap_cmomf w=5e-6 l=5e-6 mmin=1 mmax=4 subblock=0 rfmodel=0 subscale=1 m=1 mm_ok=1
XC5 vfb2 VO_P cap_cmomf w=5e-6 l=5e-6 mmin=1 mmax=4 subblock=0 rfmodel=0 subscale=1 m=1 mm_ok=1
C6 VO_N vo1_p 1.221p m=1
C1 vfb1 vo1_n 1p m=1
C2 vo1_p vfb1 1p m=1
C7 VO_P vo1_n 1.221p m=1
.ends


* expanding   symbol:  single2dm.sym # of pins=5
** sym_path: single2dm.sym
** sch_path: single2dm.sch
.subckt single2dm vp vin vcm VSS vn
*.ipin vin
*.opin vn
*.iopin vcm
*.opin vp
*.iopin VSS
E3 vcm vn net1 VSS 0.5
E2 vp vcm net1 VSS 0.5
E1 net1 VSS vin VSS 1
.ends


* expanding   symbol:  rstring_cm.sym # of pins=4
** sym_path: rstring_cm.sym
** sch_path: rstring_cm.sch
.subckt rstring_cm VR_M VR_N VR_P VSS
*.iopin VSS
*.ipin VR_P
*.ipin VR_N
*.opin VR_M
XR1 VR_P net1 VSS rhigh w=0.5e-6 l=0.96e-6 m=1 b=0 mm_ok=1
XR2 net1 VR_M VSS rhigh w=0.5e-6 l=0.96e-6 m=1 b=0 mm_ok=1
XR3 VR_M net2 VSS rhigh w=0.5e-6 l=0.96e-6 m=1 b=0 mm_ok=1
XR4 net2 VR_N VSS rhigh w=0.5e-6 l=0.96e-6 m=1 b=0 mm_ok=1
.ends

.GLOBAL GND
.GLOBAL VDD
.end
