** sch_path: macros/filter_sky130/testbenches/xschem/amp_ol_tb.sch
**.subckt amp_ol_tb
V3 VDD GND 1.8
VIN vid GND 0 AC 1
VIINP vip vin_p 0
VIINN vin vin_n 0
V4 di_pon GND 1.8
E7 vout GND voutp voutn 1
CL2 voutp GND 1p m=1
xamp1 VDD vin_n vin_p voutp di_pon voutn GND amp
CL1 voutn GND 1p m=1
x1 vip vid vcmi GND vin single2dm
V2 vcmi GND 0.9
**** begin user architecture code


.options savecurrents

.save all
.control
set doAmpSim = 1

if $doAmpSim eq 1
	setplot const
	let f_min = 10
	let f_max = 1G
	let f_stop = 500k

	let Adc = 220
	let v_step_o = 0.9
	let v_step_i = -v_step_o/Adc

	let t_rf = 0.01u
	let t_step = 5u
	let t_delay = 0
	let t_per = 2*t_step

	let tstep = 0.001*t_step
	let tstop = 2*t_per
	let tstart = t_delay

	alter @VIN[DC] = 0.0
	alter @VIN[PULSE] = [ 0 $&v_step_i $&t_delay $&t_rf $&t_rf $&t_step $&t_per 0 ]

	ac dec 100 $&const.f_min $&const.f_max

	noise v(vout) vin dec 100 $&const.f_min $&const.f_max

	tran $&tstep $&tstop $&tstart

	setplot ac1
	let Atot = v(vout)/v(vid)

	let Amag_ol_dB = vdb(Atot)
	let Aarg_ol = 180/PI*cphase(Atot)

	**let Amag_ol_dB_1 = vdb(A1)
	**let Aarg_ol_1 = 180/PI*cphase(A1)

	**let Amag_ol_dB_2 = vdb(A2)
	**let Aarg_ol_2 = 180/PI*cphase(A2)

	meas ac Adc_ol_dB max Amag_ol_dB
	let Amag_fc = Adc_ol_dB-3

	meas ac fc find frequency when Amag_ol_dB = Amag_fc
	meas ac fug_ol find frequency when Amag_ol_dB=0
	meas ac pm find Aarg_ol when frequency=fug_ol
	let pm = 180 + pm
	print pm

	let Adc_ol_lin = 10^(Adc_ol_dB/20)
	let err_gain = 1-Adc_ol_lin/(1+Adc_ol_lin)
	print err_gain*100

	plot Amag_ol_dB Aarg_ol ylabel 'Open Loop Magnitude, Phase'

	setplot noise1
	let acgain = onoise_spectrum/inoise_spectrum
	plot onoise_spectrum ylog xlog ylabel 'Output Noise'
	*plot acgain

	setplot noise2
	print onoise_total

	setplot tran2
	let vcmo = (v(voutp)+v(voutn))/2
	plot v(vin_p) v(vin_n) v(voutp) v(voutn) vcmo
end

reset
op


*rm /foss/designs/filter/dc.txt
*show >> /foss/designs/filter/dc.txt
remzerovec
write amp_ol_tb.raw
.endc


** opencircuitdesign pdks install
.lib $::SKYWATER_MODELS/sky130.lib.spice tt


.include [file rootname [file tail [xschem get schname]]].save

**** end user architecture code
**.ends

* expanding   symbol:  amp.sym # of pins=7
** sym_path: amp.sym
** sch_path: amp.sch
.subckt amp VDD VI_N VI_P VO_P di_pon VO_N VSS
*.iopin VSS
*.iopin VDD
*.ipin VI_P
*.ipin di_pon
*.ipin VI_N
*.opin VO_P
*.opin VO_N
xr1 vfb1 vo1_n vo1_p VSS rstring_cm
xr2 vfb2 VO_P VO_N VSS rstring_cm
XM6 vbp vbp VDD VDD sg13_lv_pmos w=0.15u l=0.13u ng=1 m=1 mm_ok=1
XM7 viref1 vbp VDD VDD sg13_lv_pmos w=0.15u l=0.13u ng=1 m=1 mm_ok=1
XM8 VO_N vfb2 VDD VDD sg13_lv_pmos w=0.15u l=0.13u ng=1 m=1 mm_ok=1
XM9 VO_P vfb2 VDD VDD sg13_lv_pmos w=0.15u l=0.13u ng=1 m=1 mm_ok=1
XM10 vbncm vbp VDD VDD sg13_lv_pmos w=0.15u l=0.13u ng=1 m=1 mm_ok=1
XM12 vo1_n vfb1 VSS VSS sg13_lv_nmos w=6u l=0.13u ng=1 m=1 mm_ok=1
XM13 vo1_p vfb1 VSS VSS sg13_lv_nmos w=6u l=0.13u ng=1 m=1 mm_ok=1
XM14 VO_N vo1_p VSS VSS sg13_lv_nmos w=0.15u l=0.13u ng=1 m=1 mm_ok=1
XM15 VO_P vo1_n VSS VSS sg13_lv_nmos w=0.15u l=0.13u ng=1 m=1 mm_ok=1
XM16 vfb2 vbncm VSS VSS sg13_lv_nmos w=0.15u l=0.13u ng=1 m=1 mm_ok=1
XM17 vbncm vbncm VSS VSS sg13_lv_nmos w=0.15u l=0.13u ng=1 m=1 mm_ok=1
XR1 vbp vrref_sw VSS rhigh w=0.5e-6 l=0.96e-6 m=1 b=0 mm_ok=1
XC3 vbp VDD cap_cmomf w=5e-6 l=5e-6 mmin=1 mmax=4 subblock=0 rfmodel=0 subscale=1 m=1 mm_ok=1
XC4 VO_N vfb2 cap_cmomf w=5e-6 l=5e-6 mmin=1 mmax=4 subblock=0 rfmodel=0 subscale=1 m=1 mm_ok=1
XC5 vfb2 VO_P cap_cmomf w=5e-6 l=5e-6 mmin=1 mmax=4 subblock=0 rfmodel=0 subscale=1 m=1 mm_ok=1
C6 VO_N vo1_p 1.221p m=1
C1 vfb1 vo1_n 1p m=1
C2 vo1_p vfb1 1p m=1
C7 VO_P vo1_n 1.221p m=1
.ends


* expanding   symbol:  single2dm.sym # of pins=5
** sym_path: single2dm.sym
** sch_path: single2dm.sch
.subckt single2dm vp vin vcm VSS vn
*.ipin vin
*.opin vn
*.iopin vcm
*.opin vp
*.iopin VSS
E3 vcm vn net1 VSS 0.5
E2 vp vcm net1 VSS 0.5
E1 net1 VSS vin VSS 1
.ends


* expanding   symbol:  rstring_cm.sym # of pins=4
** sym_path: rstring_cm.sym
** sch_path: rstring_cm.sch
.subckt rstring_cm VR_M VR_N VR_P VSS
*.iopin VSS
*.ipin VR_P
*.ipin VR_N
*.opin VR_M
XR1 VR_P net1 VSS rhigh w=0.5e-6 l=0.96e-6 m=1 b=0 mm_ok=1
XR2 net1 VR_M VSS rhigh w=0.5e-6 l=0.96e-6 m=1 b=0 mm_ok=1
XR3 VR_M net2 VSS rhigh w=0.5e-6 l=0.96e-6 m=1 b=0 mm_ok=1
XR4 net2 VR_N VSS rhigh w=0.5e-6 l=0.96e-6 m=1 b=0 mm_ok=1
.ends

.GLOBAL GND
.GLOBAL VDD
.end
